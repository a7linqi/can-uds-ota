# Keil uVision project app.uvprojx, settings and files
target app_ZG_UNCONFIGURED (6070000::V6.7::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x8010000,0xF0000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") ELITTLE
  output: app_ZG_UNCONFIGURED
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F407xx,__MICROLIB,FLASH_TOTAL_SIZE=1048576u,OTA_ENABLE_FLASHING=0,OTA_ENABLE_BOOT_HANDOFF=0,OTA_ENABLE_WATCHDOG=0
  c misc: -std=c99 -Wall -Wextra -mfloat-abi=soft
  c include: ..\include;..\platform\stm32f407\include;..\third_party\ed25519
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\firmware\linker\app_ZG.sct
  link misc: --entry Reset_Handler --strict
  group Portable core
    ../src/core/: boot.c crc32.c image.c isotp.c metadata.c signature.c uds.c watchdog_policy.c
  group Optional chip driver
    ../src/driver/: spi_nor.c
  group STM32 adapter
    ../platform/stm32f407/src/: stm32_arch.c stm32_can.c stm32_diag.c stm32_eeprom.c stm32_handoff.c stm32_internal_flash.c stm32_ports.c stm32_spi_flash.c system_minimal.c
  group Ed25519 (vendored)
    ../third_party/ed25519/: fe.c ge.c keypair.c sc.c sha512.c sign.c verify.c
  group UNCONFIGURED board
    ../platform/stm32f407/board/: board_unconfigured.c
  group app
    ../firmware/app/: main.c
  group ST startup
    ../third_party/st/: startup_stm32f407xx.s
target app_ZE_UNCONFIGURED (6070000::V6.7::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x8010000,0x70000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") ELITTLE
  output: app_ZE_UNCONFIGURED
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F407xx,__MICROLIB,FLASH_TOTAL_SIZE=524288u,OTA_ENABLE_FLASHING=0,OTA_ENABLE_BOOT_HANDOFF=0,OTA_ENABLE_WATCHDOG=0
  c misc: -std=c99 -Wall -Wextra -mfloat-abi=soft
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\firmware\linker\app_ZE.sct
  link misc: --entry Reset_Handler --strict
